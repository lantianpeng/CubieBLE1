# Keil uVision project airsync.uvprojx, settings and files
target flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: airsync
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu  --preinclude=autoconf_app.h
  c include: ..\..\..\..\include;..\..\..\..\arch;..\..\..\..\include\arch\arm;..\..\..\..\include\zephyr;..\..\..\..\include\net;..\..\..\..\include\shell;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\soc\atb110x;..\..\..\..\include\arch\arm\cortex_m\cmsis\Include;..\..\..\..\lib\libc\minimal\include;..\..\..\..\include\generated;..\..\..\..\boards;..\src\include;..\..\..\..\subsys\bluetooth;..\..\..\..\subsys\bluetooth\host;..\src\profile;..\..\gatt;..\..\..\..\subsys\bluetooth\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_zephyr_symdefs.txt --datacompressor=off
  group startup
    ../../../../ext/lib/actions/startup/: startup.s system.c entry.c
    ../../../../arch/soc/atb110x/: soc_patch.c soc_pm.c
  group app
    ../src/: main.c mem_manager.c
  group profile
    ../src/wechat/service/: wechat_service.c
    ../src/wechat/MmBp_helper/: wechat_protocol.c
  group board
    ../../../../boards/: board.c
  group drivers
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/timer/: sys_clock_init.c
    ../../../../drivers/uart/: uart_acts.c
    ../../../../drivers/bluetooth/hci/: llc_hci.c llcc.c
  group kernel
    ../../../../kernel/: device.c kernel_config_init.c system_work_q.c
  group libpatch
    ../../../../subsys/bluetooth/host/: bt_host_config_init.c bt_host_patch.c storage.c
  group mmbp_embedded_1.0.4
    ../src/wechat/MmBp_Embedded_1.0.4/crc32/: crc32.c
    ../src/wechat/MmBp_Embedded_1.0.4/protobuf/: epb.c epb_MmBp.c
