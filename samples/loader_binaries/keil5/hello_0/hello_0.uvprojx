# Keil uVision project hello_0.uvprojx, settings and files
target rmc (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: hello_0
  AfterMake: .\AfterBuild.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu  --preinclude=autoconf_app.h
  c include: ..\hello_0;..\..\..\..\include;..\..\..\..\arch;..\..\..\..\include\arch\arm;..\..\..\..\include\zephyr;..\..\..\..\include\net;..\..\..\..\include\shell;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\soc\atb110x;..\..\..\..\include\arch\arm\cortex_m\cmsis\Include;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\bluetooth;..\..\..\..\subsys\bluetooth\host;..\..\..\..\subsys\bluetooth\common;..\..\src\hello_0\include;..\..\..\..\include\generated;..\..\src\loader;..\..\..\..\boards;..\..\..\..\ext\lib\actions\include
  asm define: ASM_APP_NOR_ADDR=0x10000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_zephyr_symdefs.txt --datacompressor=off
  group startup
    ../../../../ext/lib/actions/startup/: startup.s system.c entry.c
    ../../../../arch/soc/atb110x/: soc_pm.c soc_patch.c
  group app
    ../../src/hello_0/: main.c
  group board
    ../../../../boards/: board.c
  group drivers
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/timer/: sys_clock_init.c
    ../../../../drivers/uart/: uart_acts.c
    ../../../../drivers/watchdog/: wdg_acts.c
  group kernel
    ../../../../kernel/: device.c system_work_q.c kernel_config_init.c
