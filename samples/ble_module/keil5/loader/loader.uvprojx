# Keil uVision project loader.uvprojx, settings and files
target loader (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: loader
  AfterMake: .\AfterBuild.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\src\loader\CMSIS\Include;..\..\..\..\ext\lib\actions\startup
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_symdefs.txt --datacompressor=off  --no_remove
  group src
    ../../src/loader/: startup.s system.c main.c partition.c
    ../../../../ext/lib/actions/startup/: uart_adfu.c
