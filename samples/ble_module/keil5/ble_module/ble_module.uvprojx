# Keil uVision project ble_module.uvprojx, settings and files
target ble_module (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_module
  AfterMake: .\AfterBuild.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu  --preinclude=autoconf_rmc.h
  c include: ..\peripheral_rmc;..\..\..\..\include;..\..\..\..\arch;..\..\..\..\include\arch\arm;..\..\..\..\include\zephyr;..\..\..\..\include\net;..\..\..\..\include\shell;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\soc\atb110x;..\..\..\..\include\arch\arm\cortex_m\cmsis\Include;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\bluetooth;..\..\..\..\subsys\bluetooth\host;..\..\..\..\subsys\bluetooth\common;..\..\src\ble_module\include;..\..\..\..\include\generated;..\..\src\loader;..\..\..\..\boards;..\..\..\..\lib\actions\include;..\..\..\..\ext\lib\actions\include;..\..\src\ble_module\at
  asm define: ASM_APP_NOR_ADDR=0x10000
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_zephyr_symdefs.txt --datacompressor=off
  group startup
    ../../../../ext/lib/actions/startup/: startup.s entry.c system.c
    ../../../../arch/soc/atb110x/: soc_pm.c soc_patch.c
  group app
    ../../src/ble_module/: main.c app_ble.c app_input.c version.c misc.c
    ../../src/ble_module/at/: at_cmd.c act_data.c uart_pipe.c
  group app_framework
    ../../../../ext/lib/actions/framework/: msg_manager.c led_manager.c
  group profile
    ../../src/ble_module/profile/: bas.c dis.c wp.c qpps.c
    ../../../../ext/lib/actions/ota/: ota_profile.c
  group ble_host
    ../../src/ble_module/ble_stack/: storage.c
    ../../../../subsys/bluetooth/host/: bt_host_config_init.c bt_host_patch.c
  group board
    ../../../../boards/: board.c
  group hal
    ../../../../ext/lib/actions/hal/: led_hal.c
  group drivers
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/timer/: sys_clock_init.c
    ../../../../drivers/bluetooth/hci/: llcc.c llc_hci.c
    ../../../../drivers/dma/: dma_acts.c
    ../../../../drivers/flash/: xspi_nor_acts.c
    ../../../../drivers/nvram/: nvram_config.c
    ../../../../drivers/adc/: adc_acts.c
    ../../../../drivers/pwm/: pwm_acts.c
    ../../../../drivers/watchdog/: wdg_acts.c
    ../../../../drivers/gpio/: gpio_acts.c
    ../../src/ble_module/drivers/: uart_acts.c
  group kernel
    ../../../../kernel/: device.c system_work_q.c kernel_config_init.c mailbox.c
  group ota
    ../../../../ext/lib/actions/ota/: ota.c ota_dc.c ota_ft.c ota_storage.c
