# Keil uVision project nvram.uvprojx, settings and files
target flash (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: nvram
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu  --preinclude=autoconf_app.h
  c include: ..\..\..\..\include;..\..\..\..\arch;..\..\..\..\include\arch\arm;..\..\..\..\include\zephyr;..\..\..\..\include\net;..\..\..\..\include\shell;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\soc\atb110x;..\..\..\..\include\arch\arm\cortex_m\cmsis\Include;..\..\..\..\lib\libc\minimal\include;..\..\..\..\include\generated;..\..\..\..\boards;..\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_zephyr_symdefs.txt --datacompressor=off
  group startup
    ../../../../ext/lib/actions/startup/: startup.s system.c entry.c
    ../../../../arch/soc/atb110x/: soc_patch.c soc_pm.c
  group app
    ../src/: main.c
  group board
    ../../../../boards/: board.c
  group drivers
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/timer/: sys_clock_init.c
    ../../../../drivers/uart/: uart_acts.c
    ../../../../drivers/dma/: dma_acts.c
    ../../../../drivers/flash/: xspi_nor_acts.c
    ../../../../drivers/nvram/: nvram_config.c
  group kernel
    ../../../../kernel/: device.c kernel_config_init.c system_work_q.c
target ram (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: as above
  output: i2c
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu  --preinclude=autoconf_app.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link.sct
  link misc: as above
