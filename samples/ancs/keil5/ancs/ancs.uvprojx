# Keil uVision project ancs.uvprojx, settings and files
target spi_xip (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ancs
  AfterMake: .\AfterBuild.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_SPI0_XIP
  c misc: --gnu  --preinclude=autoconf_app.h
  c include: ..\..\..\..\include;..\..\..\..\arch;..\..\..\..\include\arch\arm;..\..\..\..\include\zephyr;..\..\..\..\include\net;..\..\..\..\include\shell;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\soc\atb110x;..\..\..\..\include\arch\arm\cortex_m\cmsis\Include;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\bluetooth;..\..\..\..\subsys\bluetooth\host;..\..\..\..\subsys\bluetooth\common;..\..\src\ancs\include;..\..\..\..\include\generated;..\..\src\loader;..\..\..\..\boards;..\..\..\..\lib\actions\include;..\..\..\..\ext\lib\actions\include;..\..\..\..\drivers\bluetooth\hci
  asm define: ASM_APP_NOR_ADDR=0x10000 CONFIG_SPI0_XIP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link_xip.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_zephyr_symdefs.txt --datacompressor=off
  group startup
    ../../../../ext/lib/actions/startup/: startup.s system.c entry.c
    ../../../../arch/soc/atb110x/: soc_pm.c soc_patch.c
  group app
    ../../src/ancs/: main.c app_ble.c version.c ancs_service.c ancs_service_disc.c app_disc.c
  group app_framework
    ../../../../ext/lib/actions/framework/: msg_manager.c
  group profile
    ../../src/ancs/profile/: bas.c dis.c
    ../../../../ext/lib/actions/ota/: ota_profile.c
  group ble_host
    ../../src/ancs/ble_stack/: storage.c
    ../../../../subsys/bluetooth/host/: bt_host_patch.c bt_host_config_init.c
  group board
    ../../../../boards/: board.c
  group drivers
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/timer/: sys_clock_init.c
    ../../../../drivers/uart/: uart_acts.c
    ../../../../drivers/bluetooth/hci/: llcc.c llc_hci.c
    ../../../../drivers/dma/: dma_acts.c
    ../../../../drivers/flash/: xspi_nor_acts.c
    ../../../../drivers/nvram/: nvram_config.c
    ../../../../drivers/watchdog/: wdg_acts.c
  group kernel
    ../../../../kernel/: device.c system_work_q.c kernel_config_init.c
  group subsys_shell
    ../../../../subsys/shell/: shell.c shell_service.c kernel_service.c
  group ota
    ../../../../ext/lib/actions/ota/: ota.c ota_dc.c ota_ft.c ota_storage.c
