# Keil uVision project rmc.uvprojx, settings and files
target spi_xip (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: rcu
  AfterMake: .\AfterBuild.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_SPI0_XIP
  c misc: --gnu  --preinclude=autoconf_rmc.h
  c include: ..\peripheral_rmc;..\..\..\..\include;..\..\..\..\arch;..\..\..\..\include\arch\arm;..\..\..\..\include\zephyr;..\..\..\..\include\net;..\..\..\..\include\shell;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\soc\atb110x;..\..\..\..\include\arch\arm\cortex_m\cmsis\Include;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\bluetooth;..\..\..\..\subsys\bluetooth\host;..\..\..\..\subsys\bluetooth\common;..\..\src\peripheral_rmc\include;..\..\..\..\include\generated;..\..\src\loader;..\..\..\..\boards;..\..\..\..\ext\lib\actions\include;..\..\..\bluetooth\gatt\hid;..\..\..\bluetooth\gatt;..\..\..\..\drivers\irc;..\..\src\peripheral_rmc\hal;..\..\src\peripheral_rmc\drivers;..\..\..\..\ext\lib\actions\libAL
  asm define: ASM_APP_NOR_ADDR=0x10000 CONFIG_SPI0_XIP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link_xip.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_zephyr_symdefs.txt --datacompressor=off
  group startup
    ../../../../ext/lib/actions/startup/: startup.s system.c entry.c
    ../../../../arch/soc/atb110x/: soc_pm.c soc_patch.c
  group app
    ../../src/peripheral_rmc/: main.c system_app_ble.c system_app_input.c system_app_sm.c system_app_timer.c system_app_led.c system_app_batt.c version.c system_app_audio.c system_app_storage.c
  group app_framework
    ../../../../ext/lib/actions/framework/: input_manager.c led_manager.c msg_manager.c
  group profile
    ../../../../ext/lib/actions/ota/: ota_profile.c
    ../../../bluetooth/gatt/hid/: bas.c dis.c
    ../../../bluetooth/gatt/: wp.c
  group hal
    ../../../../ext/lib/actions/hal/: irc_hal.c key_hal.c led_hal.c irc_protocol.c audioin_hal.c audio_out_hal.c
    ../../src/peripheral_rmc/hal/: adckey_hal.c
  group bt_host
    ../../../../subsys/bluetooth/host/: bt_host_patch.c bt_host_config_init.c storage.c
  group board
    ../../../../boards/: board.c
  group drivers
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/timer/: sys_clock_init.c timer_acts.c
    ../../../../drivers/uart/: uart_acts.c
    ../../../../drivers/bluetooth/hci/: llcc.c llc_hci.c
    ../../../../drivers/dma/: dma_acts.c
    ../../../../drivers/flash/: xspi_nor_acts.c
    ../../../../drivers/nvram/: nvram_config.c
    ../../../../drivers/gpio/: gpio_acts.c
    ../../../../drivers/adc/: adc_acts.c
    ../../../../drivers/pwm/: pwm_acts.c
    ../../../../drivers/irc/: irc_acts.c sw_irc_acts.c
    ../../src/peripheral_rmc/drivers/: adckey_acts.c
    ../../../../drivers/input/: mxkeypad_acts.c
    ../../../../drivers/watchdog/: wdg_acts.c
    ../../../../arch/soc/atb110x/: spicache.c
    ../../../../drivers/audio/: audio_in_acts.c audio_out_acts.c
  group kernel
    ../../../../kernel/: device.c system_work_q.c kernel_config_init.c
  group ota
    ../../../../ext/lib/actions/ota/: ota_dc.c ota_ft.c ota.c ota_storage.c
  group lib
    ../../../../ext/lib/actions/libAL/: asc_enc2.lib asc_enc3.lib asc_dec3.lib
  group subsys_shell
    ../../../../subsys/shell/: kernel_service.c shell.c shell_service.c
