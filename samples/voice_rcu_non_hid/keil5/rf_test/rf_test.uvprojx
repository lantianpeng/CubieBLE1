# Keil uVision project rf_test.uvprojx, settings and files
target spi_xip (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: rf_test
  AfterMake: .\AfterBuild.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_SPI0_XIP
  c misc: --gnu  --preinclude=autoconf_app.h
  c include: ..\peripheral_rmc;..\..\..\..\include;..\..\..\..\arch;..\..\..\..\include\zephyr;..\..\..\..\include\net;..\..\..\..\include\arch\arm;..\..\..\..\include\shell;..\..\..\..\include\drivers;..\..\..\..\kernel\include;..\..\..\..\arch\soc\atb110x;..\..\..\..\include\arch\arm\cortex_m\cmsis\Include;..\..\..\..\lib\libc\minimal\include;..\..\..\..\subsys\bluetooth;..\..\..\..\subsys\bluetooth\host;..\..\src\peripheral_rmc\include;..\..\..\..\include\generated;..\..\src\loader;..\..\..\..\boards;..\..\..\..\drivers\bluetooth\hci;..\..\src\rf_test\include;..\..\..\..\ext\lib\actions\include
  asm define: ASM_APP_NOR_ADDR=0x50000 CONFIG_SPI0_XIP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\link_xip.sct
  link misc: ..\..\..\..\arch\soc\atb110x\rom_zephyr_symdefs.txt --datacompressor=off
  group startup
    ../../../../ext/lib/actions/startup/: startup.s system.c entry.c
    ../../../../arch/soc/atb110x/: soc_pm.c soc_patch.c
  group app
    ../../src/rf_test/: main.c
    ../../../../subsys/bluetooth/host/: hci_raw.c
    ../../../../ext/lib/actions/framework/: led_manager.c
  group hal
    ../../../../ext/lib/actions/hal/: led_hal.c
  group board
    ../../../../boards/: board.c
  group drivers
    ../../../../drivers/timer/: sys_clock_init.c
    ../../../../drivers/uart/: uart_acts.c
    ../../../../drivers/console/: uart_console.c
    ../../../../drivers/bluetooth/hci/: llcc.c llc_hci.c
    ../../../../drivers/pwm/: pwm_acts.c
  group kernel
    ../../../../kernel/: device.c system_work_q.c kernel_config_init.c
